# Repository FirstTestStation/InterconnectIO_Board (continued)

## KiCad design Interconnect.kicad_pcb (continued)

Schematic: Pmaster.kicad_sch, InterconnectIO Board

Parts:
NT233: M2_00; NetTie-2_Front1.0mm
NT234: S1_00; NetTie-2_Front1.0mm
NT235: M2_01; NetTie-2_Front1.0mm
NT236: S1_01; NetTie-2_Front1.0mm
NT237: M2_02; NetTie-2_Front1.0mm
NT238: M2_EN; NetTie-2_Front1.0mm
NT239: S1_02; NetTie-2_Front1.0mm
NT240: S1_EN; NetTie-2_Front1.0mm
NT241: M2_03; NetTie-2_Front1.0mm
NT242: S1_03; NetTie-2_Front1.0mm
NT243: M2_04; NetTie-2_Front1.0mm
NT244: M2_ADCR; NetTie-2_Front1.0mm
NT245: S1_04; NetTie-2_Front1.0mm
NT246: S1_ADC; NetTie-2_Front1.0mm
NT247: M2_05; NetTie-2_Front1.0mm
NT248: M2_ADC2; NetTie-2_Front1.0mm
NT249: S1_05; NetTie-2_Front1.0mm
NT250: S1_28; NetTie-2_Front1.0mm
NT251: M2_06; NetTie-2_Front1.0mm
NT252: M2_ADC1; NetTie-2_Front1.0mm
NT253: S1_06; NetTie-2_Front1.0mm
NT254: S1_27; NetTie-2_Front1.0mm
NT255: M2_07; NetTie-2_Front1.0mm
NT256: M2_ADC0; NetTie-2_Front1.0mm
NT257: S1_07; NetTie-2_Front1.0mm
NT258: S1_26; NetTie-2_Front1.0mm
NT259: M2_08; NetTie-2_Front1.0mm
NT260, NT264: M2_22; NetTie-2_Front1.0mm
NT261: S1_08; NetTie-2_Front1.0mm
NT262: S1_RUN; NetTie-2_Front1.0mm
NT263: M2_09; NetTie-2_Front1.0mm
NT265: S1_09; NetTie-2_Front1.0mm
NT266: S1_22; NetTie-2_Front1.0mm
NT267: M2_10; NetTie-2_Front1.0mm
NT268: M2_21; NetTie-2_Front1.0mm
NT269: S1_10; NetTie-2_Front1.0mm
NT270: S1_21; NetTie-2_Front1.0mm
NT271: M2_11; NetTie-2_Front1.0mm
NT272: M2_20; NetTie-2_Front1.0mm
NT273: S1_11; NetTie-2_Front1.0mm
NT274: S1_20; NetTie-2_Front1.0mm
NT275: M2_12; NetTie-2_Front1.0mm
NT276: M2_19; NetTie-2_Front1.0mm
NT277: S1_12; NetTie-2_Front1.0mm
NT278: S1_19; NetTie-2_Front1.0mm
NT279: M2_13; NetTie-2_Front1.0mm
NT280: M2_18; NetTie-2_Front1.0mm
NT281: S1_13; NetTie-2_Front1.0mm
NT282: S1_18; NetTie-2_Front1.0mm
NT283: M2_14; NetTie-2_Front1.0mm
NT284: M2_17; NetTie-2_Front1.0mm
NT285: S1_14; NetTie-2_Front1.0mm
NT286: S1_17; NetTie-2_Front1.0mm
NT287: M2_15; NetTie-2_Front1.0mm
NT288: M2_16; NetTie-2_Front1.0mm
NT289: S1_15; NetTie-2_Front1.0mm
NT290: S1_16; NetTie-2_Front1.0mm
NT291: S2_00; NetTie-2_Front1.0mm
NT292: S3_00; NetTie-2_Front1.0mm
NT293: S2_01; NetTie-2_Front1.0mm
NT294: S3_01; NetTie-2_Front1.0mm
NT295: S2_02; NetTie-2_Front1.0mm
NT296: S2_EN; NetTie-2_Front1.0mm
NT297: S3_02; NetTie-2_Front1.0mm
NT298: S3_EN; NetTie-2_Front1.0mm
NT299: S2_03; NetTie-2_Front1.0mm
NT300: S3_03; NetTie-2_Front1.0mm
NT301: S2_04; NetTie-2_Front1.0mm
NT302: S2_ADC; NetTie-2_Front1.0mm
NT303: S3_04; NetTie-2_Front1.0mm
NT304: S3_ADC; NetTie-2_Front1.0mm
NT305: S2_05; NetTie-2_Front1.0mm
NT306: S2_28; NetTie-2_Front1.0mm
NT307: S3_05; NetTie-2_Front1.0mm
NT308: S3_28; NetTie-2_Front1.0mm
NT309: S2_06; NetTie-2_Front1.0mm
NT310: S2_27; NetTie-2_Front1.0mm
NT311: S3_06; NetTie-2_Front1.0mm
NT312: S3_27; NetTie-2_Front1.0mm
NT313: S2_07; NetTie-2_Front1.0mm
NT314: S2_26; NetTie-2_Front1.0mm
NT315: S3_07; NetTie-2_Front1.0mm
NT316: S3_26; NetTie-2_Front1.0mm
NT317: S2_08; NetTie-2_Front1.0mm
NT318: S2_RUN; NetTie-2_Front1.0mm
NT319: S3_08; NetTie-2_Front1.0mm
NT320: S3_RUN; NetTie-2_Front1.0mm
NT321: S2_09; NetTie-2_Front1.0mm
NT322: S2_22; NetTie-2_Front1.0mm
NT323: S3_09; NetTie-2_Front1.0mm
NT324: S3_22; NetTie-2_Front1.0mm
NT325: S2_10; NetTie-2_Front1.0mm
NT326: S2_21; NetTie-2_Front1.0mm
NT327: S3_10; NetTie-2_Front1.0mm
NT328: S3_21; NetTie-2_Front1.0mm
NT329: S2_11; NetTie-2_Front1.0mm
NT330: S2_20; NetTie-2_Front1.0mm
NT331: S3_11; NetTie-2_Front1.0mm
NT332: S3_20; NetTie-2_Front1.0mm
NT333: S2_12; NetTie-2_Front1.0mm
NT334: S2_19; NetTie-2_Front1.0mm
NT335: S3_12; NetTie-2_Front1.0mm
NT336: S3_19; NetTie-2_Front1.0mm
NT337: S2_13; NetTie-2_Front1.0mm
NT338: S2_18; NetTie-2_Front1.0mm
NT339: S3_13; NetTie-2_Front1.0mm
NT340: S3_18; NetTie-2_Front1.0mm
NT341: S2_14; NetTie-2_Front1.0mm
NT342: S2_17; NetTie-2_Front1.0mm
NT343: S3_14; NetTie-2_Front1.0mm
NT344: S3_17; NetTie-2_Front1.0mm
NT345: S2_15; NetTie-2_Front1.0mm
NT346: S2_16; NetTie-2_Front1.0mm
NT347: S3_15; NetTie-2_Front1.0mm
NT348: S3_16; NetTie-2_Front1.0mm
R1, R10, R11, R12, R13, R14, R16, R17: 4.7K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
TP26, TP41: S2_VBUS; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP27: S1_VBUS; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP28: M2_3V3EN; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP29: S1_3V3EN; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP30: M2_3V3; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP31: S1_3V3; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP32: M2_ADC_VREF; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP33: S1_ADC_VREF; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP34: M2_RUN; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP35: S1_SWDIO; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP36: S1_SWGND; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP37: M2_SWDIO; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP38: S1_SWCLK; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP39: M2_SWGND; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP40: M2_SWCLK; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP42: S3_VBUS; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP43: S2_3V3EN; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP44: S3_3V3EN; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP45: S2_3V3; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP46: S3_3V3; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP47: S2_ADC_VREF; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP48: S3_ADC_VREF; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP49: S2_SWDIO; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP50: S3_SWDIO; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP51: S2_SWGND; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP52: S3_SWGND; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP53: S2_SWCLK; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP54: S3_SWCLK; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
U1, U2, U3, U4: Pico; RPi_Pico_SMD_TH
U5: LM4040LP-3; TO-92_Inline

Connections:
1WIRE: NT267.1; also elsewhere on the board
/Pico_master/S1_I2C_ID0: NT258.2, R12.2
/Pico_master/S1_I2C_ID1: NT254.2, R13.2
/Pico_master/S2_I2C_ID0: NT314.2, R14.2
/Pico_master/S2_I2C_ID1: NT310.2, R1.2
/Pico_master/S3_I2C_ID0: NT316.2, R16.2
/Pico_master/S3_I2C_ID1: NT312.2, R17.2
/Pico_master/SYNC: NT264.2, NT266.2, NT322.2, NT324.2
ADC0: NT256.1; also elsewhere on the board
ADC1: NT252.1; also elsewhere on the board
B1S_D: NT334.1; also elsewhere on the board
B2S_D: NT338.1; also elsewhere on the board
B3S_D: NT336.1; also elsewhere on the board
B4S_D: NT340.1; also elsewhere on the board
B10_D: NT291.1; also elsewhere on the board
B11_D: NT293.1; also elsewhere on the board
B12_D: NT295.1; also elsewhere on the board
B13_D: NT299.1; also elsewhere on the board
B14_D: NT301.1; also elsewhere on the board
B15_D: NT305.1; also elsewhere on the board
B16_D: NT309.1; also elsewhere on the board
B17_D: NT313.1; also elsewhere on the board
B20_D: NT325.1; also elsewhere on the board
B21_D: NT329.1; also elsewhere on the board
B22_D: NT333.1; also elsewhere on the board
B23_D: NT337.1; also elsewhere on the board
B24_D: NT341.1; also elsewhere on the board
B25_D: NT345.1; also elsewhere on the board
B26_D: NT346.1; also elsewhere on the board
B27_D: NT342.1; also elsewhere on the board
B30_D: NT292.1; also elsewhere on the board
B31_D: NT294.1; also elsewhere on the board
B32_D: NT297.1; also elsewhere on the board
B33_D: NT300.1; also elsewhere on the board
B34_D: NT303.1; also elsewhere on the board
B35_D: NT307.1; also elsewhere on the board
B36_D: NT311.1; also elsewhere on the board
B37_D: NT315.1; also elsewhere on the board
B40_D: NT327.1; also elsewhere on the board
B41_D: NT331.1; also elsewhere on the board
B42_D: NT335.1; also elsewhere on the board
B43_D: NT339.1; also elsewhere on the board
B44_D: NT343.1; also elsewhere on the board
B45_D: NT347.1; also elsewhere on the board
B46_D: NT348.1; also elsewhere on the board
B47_D: NT344.1; also elsewhere on the board
BEEPER: NT271.1; also elsewhere on the board
CTRL: NT278.1; also elsewhere on the board
ERROR_LED: NT276.1; also elsewhere on the board
EXT_16: NT288.1; also elsewhere on the board
EXT_17: NT284.1; also elsewhere on the board
FLAG: NT282.1; also elsewhere on the board
GND: R1.1, R12.1, R13.1, R14.1, R16.1, R17.1, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U2.3 (GND), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.33 (AGND), U2.38 (GND), U3.3 (GND), U3.8 (GND), U3.13 (GND), U3.18 (GND), U3.23 (GND), U3.28 (GND), U3.33 (AGND), U3.38 (GND), U4.3 (GND), U4.8 (GND), U4.13 (GND), U4.18 (GND), U4.23 (GND), U4.28 (GND), U4.33 (AGND), U4.38 (GND), U5.3 (A); also elsewhere on the board
HPR1: NT319.1; also elsewhere on the board
I2C0_SCL: NT268.1, NT270.2, NT326.2, NT328.2, R10.1; also elsewhere on the board
I2C0_SDA: NT272.1, NT274.2, NT330.2, NT332.2, R11.1; also elsewhere on the board
I2C1_SCL: NT255.1; also elsewhere on the board
I2C1_SDA: NT251.1; also elsewhere on the board
LPR1: NT317.1; also elsewhere on the board
LPR2: NT321.1; also elsewhere on the board
M1_IO8: NT259.1; also elsewhere on the board
M1_IO9: NT263.1; also elsewhere on the board
M1_IO28: NT248.1; also elsewhere on the board
MSR_3V3: TP30.1, U1.36 (3V3); also elsewhere on the board
unnamed: NT233.2, U1.1 (GPIO0)
unnamed: NT234.2, U2.1 (GPIO0)
unnamed: NT235.2, U1.2 (GPIO1)
unnamed: NT236.2, U2.2 (GPIO1)
unnamed: NT237.2, U1.4 (GPIO2)
unnamed: NT238.1, U1.37 (3V3_EN)
unnamed: NT238.2, TP28.1
unnamed: NT239.2, U2.4 (GPIO2)
unnamed: NT240.1, U2.37 (3V3_EN)
unnamed: NT240.2, TP29.1
unnamed: NT241.2, U1.5 (GPIO3)
unnamed: NT242.2, U2.5 (GPIO3)
unnamed: NT243.2, U1.6 (GPIO4)
unnamed: NT244.1, U1.35 (ADC_VREF)
unnamed: NT244.2, TP32.1, U5.2 (K)
unnamed: NT245.2, U2.6 (GPIO4)
unnamed: NT246.1, U2.35 (ADC_VREF)
unnamed: NT246.2, TP33.1
unnamed: NT247.2, U1.7 (GPIO5)
unnamed: NT248.2, U1.34 (GPIO28_ADC2)
unnamed: NT249.2, U2.7 (GPIO5)
unnamed: NT250.2, U2.34 (GPIO28_ADC2)
unnamed: NT251.2, U1.9 (GPIO6)
unnamed: NT252.2, U1.32 (GPIO27_ADC1)
unnamed: NT253.2, U2.9 (GPIO6)
unnamed: NT254.1, U2.32 (GPIO27_ADC1)
unnamed: NT255.2, U1.10 (GPIO7)
unnamed: NT256.2, U1.31 (GPIO26_ADC0)
unnamed: NT257.2, U2.10 (GPIO7)
unnamed: NT258.1, U2.31 (GPIO26_ADC0)
unnamed: NT259.2, U1.11 (GPIO8)
unnamed: NT260.1, U1.30 (RUN)
unnamed: NT260.2, TP34.1
unnamed: NT261.2, U2.11 (GPIO8)
unnamed: NT262.1, U2.30 (RUN)
unnamed: NT263.2, U1.12 (GPIO9)
unnamed: NT264.1, U1.29 (GPIO22)
unnamed: NT265.2, U2.12 (GPIO9)
unnamed: NT266.1, U2.29 (GPIO22)
unnamed: NT267.2, U1.14 (GPIO10)
unnamed: NT268.2, U1.27 (GPIO21)
unnamed: NT269.2, U2.14 (GPIO10)
unnamed: NT270.1, U2.27 (GPIO21)
unnamed: NT271.2, U1.15 (GPIO11)
unnamed: NT272.2, U1.26 (GPIO20)
unnamed: NT273.2, U2.15 (GPIO11)
unnamed: NT274.1, U2.26 (GPIO20)
unnamed: NT275.2, U1.16 (GPIO12)
unnamed: NT276.2, U1.25 (GPIO19)
unnamed: NT277.2, U2.16 (GPIO12)
unnamed: NT278.2, U2.25 (GPIO19)
unnamed: NT279.2, U1.17 (GPIO13)
unnamed: NT280.2, U1.24 (GPIO18)
unnamed: NT281.2, U2.17 (GPIO13)
unnamed: NT282.2, U2.24 (GPIO18)
unnamed: NT283.2, U1.19 (GPIO14)
unnamed: NT284.2, U1.22 (GPIO17)
unnamed: NT285.2, U2.19 (GPIO14)
unnamed: NT286.2, U2.22 (GPIO17)
unnamed: NT287.2, U1.20 (GPIO15)
unnamed: NT288.2, U1.21 (GPIO16)
unnamed: NT289.2, U2.20 (GPIO15)
unnamed: NT290.2, U2.21 (GPIO16)
unnamed: NT291.2, U3.1 (GPIO0)
unnamed: NT292.2, U4.1 (GPIO0)
unnamed: NT293.2, U3.2 (GPIO1)
unnamed: NT294.2, U4.2 (GPIO1)
unnamed: NT295.2, U3.4 (GPIO2)
unnamed: NT296.1, U3.37 (3V3_EN)
unnamed: NT296.2, TP43.1
unnamed: NT297.2, U4.4 (GPIO2)
unnamed: NT298.1, U4.37 (3V3_EN)
unnamed: NT298.2, TP44.1
unnamed: NT299.2, U3.5 (GPIO3)
unnamed: NT300.2, U4.5 (GPIO3)
unnamed: NT301.2, U3.6 (GPIO4)
unnamed: NT302.1, U3.35 (ADC_VREF)
unnamed: NT302.2, TP47.1
unnamed: NT303.2, U4.6 (GPIO4)
unnamed: NT304.1, U4.35 (ADC_VREF)
unnamed: NT304.2, TP48.1
unnamed: NT305.2, U3.7 (GPIO5)
unnamed: NT306.2, U3.34 (GPIO28_ADC2)
unnamed: NT307.2, U4.7 (GPIO5)
unnamed: NT308.2, U4.34 (GPIO28_ADC2)
unnamed: NT309.2, U3.9 (GPIO6)
unnamed: NT310.1, U3.32 (GPIO27_ADC1)
unnamed: NT311.2, U4.9 (GPIO6)
unnamed: NT312.1, U4.32 (GPIO27_ADC1)
unnamed: NT313.2, U3.10 (GPIO7)
unnamed: NT314.1, U3.31 (GPIO26_ADC0)
unnamed: NT315.2, U4.10 (GPIO7)
unnamed: NT316.1, U4.31 (GPIO26_ADC0)
unnamed: NT317.2, U3.11 (GPIO8)
unnamed: NT318.1, U3.30 (RUN)
unnamed: NT319.2, U4.11 (GPIO8)
unnamed: NT320.1, U4.30 (RUN)
unnamed: NT321.2, U3.12 (GPIO9)
unnamed: NT322.1, U3.29 (GPIO22)
unnamed: NT323.2, U4.12 (GPIO9)
unnamed: NT324.1, U4.29 (GPIO22)
unnamed: NT325.2, U3.14 (GPIO10)
unnamed: NT326.1, U3.27 (GPIO21)
unnamed: NT327.2, U4.14 (GPIO10)
unnamed: NT328.1, U4.27 (GPIO21)
unnamed: NT329.2, U3.15 (GPIO11)
unnamed: NT330.1, U3.26 (GPIO20)
unnamed: NT331.2, U4.15 (GPIO11)
unnamed: NT332.1, U4.26 (GPIO20)
unnamed: NT333.2, U3.16 (GPIO12)
unnamed: NT334.2, U3.25 (GPIO19)
unnamed: NT335.2, U4.16 (GPIO12)
unnamed: NT336.2, U4.25 (GPIO19)
unnamed: NT337.2, U3.17 (GPIO13)
unnamed: NT338.2, U3.24 (GPIO18)
unnamed: NT339.2, U4.17 (GPIO13)
unnamed: NT340.2, U4.24 (GPIO18)
unnamed: NT341.2, U3.19 (GPIO14)
unnamed: NT342.2, U3.22 (GPIO17)
unnamed: NT343.2, U4.19 (GPIO14)
unnamed: NT344.2, U4.22 (GPIO17)
unnamed: NT345.2, U3.20 (GPIO15)
unnamed: NT346.2, U3.21 (GPIO16)
unnamed: NT347.2, U4.20 (GPIO15)
unnamed: NT348.2, U4.21 (GPIO16)
unnamed: TP26.1, U1.40 (VBUS)
unnamed: TP27.1, U2.40 (VBUS)
unnamed: TP35.1, U2.43 (SWDIO)
unnamed: TP36.1, U2.42 (GND)
unnamed: TP37.1, U1.43 (SWDIO)
unnamed: TP38.1, U2.41 (SWCLK)
unnamed: TP39.1, U1.42 (GND)
unnamed: TP40.1, U1.41 (SWCLK)
unnamed: TP41.1, U3.40 (VBUS)
unnamed: TP42.1, U4.40 (VBUS)
unnamed: TP45.1, U3.36 (3V3)
unnamed: TP46.1, U4.36 (3V3)
unnamed: TP49.1, U3.43 (SWDIO)
unnamed: TP50.1, U4.43 (SWDIO)
unnamed: TP51.1, U3.42 (GND)
unnamed: TP52.1, U4.42 (GND)
unnamed: TP53.1, U3.41 (SWCLK)
unnamed: TP54.1, U4.41 (SWCLK)
P0_0: NT234.1; also elsewhere on the board
P0_1: NT236.1; also elsewhere on the board
P0_2: NT239.1; also elsewhere on the board
P0_3: NT242.1; also elsewhere on the board
P0_4: NT245.1; also elsewhere on the board
P0_5: NT249.1; also elsewhere on the board
P0_6: NT253.1; also elsewhere on the board
P0_7: NT257.1; also elsewhere on the board
P1_0: NT269.1; also elsewhere on the board
P1_1: NT273.1; also elsewhere on the board
P1_2: NT277.1; also elsewhere on the board
P1_3: NT281.1; also elsewhere on the board
P1_4: NT285.1; also elsewhere on the board
P1_5: NT289.1; also elsewhere on the board
P1_6: NT290.1; also elsewhere on the board
P1_7: NT286.1; also elsewhere on the board
PWR_5V: R10.2, R11.2, U1.39 (VSYS), U2.39 (VSYS), U3.39 (VSYS), U4.39 (VSYS); also elsewhere on the board
RUN: NT262.2, NT280.1, NT318.2, NT320.2; also elsewhere on the board
S1_IO8: NT261.1; also elsewhere on the board
S1_IO9: NT265.1; also elsewhere on the board
S1_IO28: NT250.1; also elsewhere on the board
S2_IO28: NT306.1; also elsewhere on the board
S3_IO28: NT308.1; also elsewhere on the board
SLV1_3V3: TP31.1, U2.36 (3V3); also elsewhere on the board
SPI0_CLK: NT237.1; also elsewhere on the board
SPI0_CS: NT247.1; also elsewhere on the board
SPI0_RX: NT243.1; also elsewhere on the board
SPI0_TX: NT241.1; also elsewhere on the board
SSR1: NT323.1; also elsewhere on the board
UART0_RX: NT235.1; also elsewhere on the board
UART0_TX: NT233.1; also elsewhere on the board
UART1-CTS: NT283.1; also elsewhere on the board
UART1-RTS: NT287.1; also elsewhere on the board
UART1-RX: NT279.1; also elsewhere on the board
UART1-TX: NT275.1; also elsewhere on the board

Notes on the sheet:
SLAVE_2
MASTER_1
SLAVE_3
SLAVE_1

Schematic: AlertDevice.kicad_sch, InterconnectIO Board

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
D36: LED; LED_D3.0mm_Clear
NT470: ERR_L; NetTie-2_Front1.0mm
R69: 220; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R71: 0; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal

Connections:
BEEP_D: R71.1; also elsewhere on the board
ERR_LED: NT470.2; also elsewhere on the board
unnamed: BZ1.2 (+), R71.2
unnamed: D36.1 (K), R69.2
unnamed: NT470.1, R69.1
PWR_5V: BZ1.1 (-), D36.2 (A); also elsewhere on the board

Notes on the sheet:
RED

Schematic: OtherRessource.kicad_sch, InterconnectIO Board

Parts:
K20, K22: TQ2-5; Relay_DPDT_FRT5
K21: G5LE-1; Relay_SPDT_Omron-G5LE-1
K23: CPC1706Y; RELAY_CPC1706Y
NT399: HRL_NO1; NetTie-2_Front1.0mm
NT400: LP1_NO1; NetTie-2_Front1.0mm
NT401: HRL_C1; NetTie-2_Front1.0mm
NT402: LP1_C1; NetTie-2_Front1.0mm
NT403: HRL_NO2; NetTie-2_Front1.0mm
NT404: LP1_NC1; NetTie-2_Front1.0mm
NT405: HRL_C2; NetTie-2_Front1.0mm
NT406: LP1_NO2; NetTie-2_Front1.0mm
NT407: LP1_C2; NetTie-2_Front1.0mm
NT408: LP1_NC2; NetTie-2_Front1.0mm
NT409, NT420: SOC1; NetTie-2_Front1.0mm
NT412: SOC2; NetTie-2_Front1.0mm
NT413: LP2_NO1; NetTie-2_Front1.0mm
NT414: LP2_C1; NetTie-2_Front1.0mm
NT415: LP2_NC1; NetTie-2_Front1.0mm
NT416: LP2_NO2; NetTie-2_Front1.0mm
NT417: LP2_C2; NetTie-2_Front1.0mm
NT418: LP2_NC2; NetTie-2_Front1.0mm
Q19, Q22, Q24: 2N2222; TO-92_Inline
R29: 10; R_Axial_Power_L38.0mm_W9.0mm_P45.72mm
R31, R35, R40: 10K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R36: 470; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
TP73: HRL_NO; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP74: HRL_C; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
TP75: HRL_NC; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork

Connections:
/OtherRessource/K1C1: K20.8, NT402.2
/OtherRessource/K1C2: K20.3, NT407.2
/OtherRessource/K2C1: K22.8, NT414.2
/OtherRessource/K2C2: K22.3, NT417.2
GND: Q19.1 (E), Q22.1 (E), Q24.1 (E); also elsewhere on the board
HPR1_R: K21.2; also elsewhere on the board
K1_LP_C1: NT402.1; also elsewhere on the board
K1_LP_C2: NT407.1; also elsewhere on the board
K1_LP_NC1: NT404.2; also elsewhere on the board
K1_LP_NC2: NT408.2; also elsewhere on the board
K1_LP_NO1: NT400.2; also elsewhere on the board
K1_LP_NO2: NT406.2; also elsewhere on the board
K2_LP_C1: NT414.1; also elsewhere on the board
K2_LP_C2: NT417.1; also elsewhere on the board
K2_LP_NC1: NT415.2; also elsewhere on the board
K2_LP_NC2: NT418.2; also elsewhere on the board
K2_LP_NO1: NT413.2; also elsewhere on the board
K2_LP_NO2: NT416.2; also elsewhere on the board
K3_HP_C1: NT401.1; also elsewhere on the board
K3_HP_C2: NT405.1; also elsewhere on the board
K3_HP_NO1: NT399.2; also elsewhere on the board
K3_HP_NO2: NT403.2; also elsewhere on the board
LPR1_R: K20.10; also elsewhere on the board
LPR2_R: K22.10; also elsewhere on the board
unnamed: K20.2, NT408.1
unnamed: K20.4, NT406.1
unnamed: K20.7, NT400.1
unnamed: K20.9, NT404.1
unnamed: K21.1, NT401.2, NT405.2, TP74.1
unnamed: K21.3, NT399.1, NT403.1, TP73.1
unnamed: K21.4, TP75.1
unnamed: K22.2, NT418.1
unnamed: K22.4, NT416.1
unnamed: K22.7, NT413.1
unnamed: K22.9, NT415.1
unnamed: K23.2, R36.1
unnamed: NT409.1, Q19.3 (C)
unnamed: NT412.1, Q22.3 (C)
unnamed: NT420.1, Q24.3 (C)
unnamed: Q19.2 (B), R31.1
unnamed: Q22.2 (B), R35.1
unnamed: Q24.2 (B), R40.1
OC1_OUT: NT409.2; also elsewhere on the board
OC2_OUT: NT412.2; also elsewhere on the board
OC3_OUT: NT420.2; also elsewhere on the board
PWR_5V: K20.1, K21.5, K22.1, R36.2; also elsewhere on the board
PWR_RES_H: R29.1; also elsewhere on the board
PWR_RES_L: R29.2; also elsewhere on the board
S1_IO28: R31.2; also elsewhere on the board
S2_IO28: R35.2; also elsewhere on the board
S3_IO28: R40.2; also elsewhere on the board
SSR1_NEG: K23.3; also elsewhere on the board
SSR1_POS: K23.4; also elsewhere on the board
SSR1_R: K23.1; also elsewhere on the board

Notes on the sheet:
10W
10A POWER RELAY
LOW POWER RELAY 1
SOLID STATE RELAY
LOW POWER RELAY 2
